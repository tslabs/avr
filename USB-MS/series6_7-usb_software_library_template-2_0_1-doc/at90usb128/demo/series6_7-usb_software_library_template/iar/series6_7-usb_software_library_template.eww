<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\series6_7-usb_software_library_template.ewp</path>
  </project>
  <batchBuild/>
</workspace>


