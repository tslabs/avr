# IAR project series6_7-usb_software_library_template.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDiagSuppress: Pe111,Pe550,Pa082
  ICCAVR.newCCIncludePaths: ..; ../conf; ../../../; ../../../../common/
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgusb1287.xcl
configuration Release (AVR)
  as the first configuration, except:
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../../../../common/lib_mcu/wdt/: wdt_drv.c
    ../../../../common/lib_mcu/uart/: uart_lib.c
  group lib_mcu
    ../../../lib_mcu/power/: power_drv.c
    ../../../lib_mcu/usb/: usb_drv.c
  group system
    ../: main.c
    ../../../../common/modules/scheduler/: scheduler.c
  group tasks
    ../: device_template_task.c host_template_task.c
  group usb
    ../../../modules/usb/: usb_task.c
  group usb/device
    ../: usb_descriptors.c usb_specific_request.c
    ../../../modules/usb/device_chap9/: usb_device_task.c usb_standard_request.c
  group usb/host
    ../../../modules/usb/host_chap9/: usb_host_enum.c usb_host_task.c
