<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\avr_usb_ms.ewp</path>
  </project>
  <batchBuild/>
</workspace>


