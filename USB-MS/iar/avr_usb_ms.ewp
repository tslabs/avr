# IAR project avr_usb_ms.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x100
  General.SCCStackSize: 0x200
  General.SCRStackSize: 64
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDiagSuppress: pe111, pe550, pa082
  ICCAVR.newCCIncludePaths: ../ms_conf/; ../lib_mcu/; ../lib_mem/; ../lib_board/; ../lib_misc/; ../lib_usb/; ../lib_fat/
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgusb1286.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  ICCAVR.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../lib_mcu/: power_drv.c uart_lib.c usb_drv.c wdt_drv.c
    ../lib_mem/: dap.c df.c df_mem.c mmc_sd.c mmc_sd_mem.c nf_drv.c nf_mngt.c nf_raw.c nf_unusual.c
    ../lib_misc/: ctrl_access.c debug.c main.c scheduler.c scsi_decoder.c storage_task.c
    ../lib_usb/: usb_descriptors.c usb_device_task.c usb_specific_request.c usb_standard_request.c usb_task.c
