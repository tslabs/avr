# IAR project EVK525-series6-ms_nf_df_sd.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x100
  General.SCCStackSize: 0x200
  General.SCRStackSize: 64
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDiagSuppress: pe111, pe550, pa082
  ICCAVR.newCCIncludePaths: ..; ../conf/; ../../../; ../../../../common/
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgusb1286.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  ICCAVR.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../../../modules/control_access/: ctrl_access.c
    ../../../lib_mcu/: debug.c
    ../../../lib_mem/df/: df.c df_mem.c
    ../: main.c storage_task.c usb_descriptors.c usb_specific_request.c
    ../../../lib_mem/mmc_sd/: mmc_sd.c mmc_sd_mem.c
    ../../../lib_mem/nf/: nf_drv.c nf_mngt.c nf_unusual.c
    ../../../lib_mcu/power/: power_drv.c
    ../../../../common/modules/scheduler/: scheduler.c
    ../../../modules/scsi_decoder/: scsi_decoder.c
    ../../../../common/lib_mcu/uart/: uart_lib.c
    ../../../modules/usb/device_chap9/: usb_device_task.c usb_standard_request.c
    ../../../lib_mcu/usb/: usb_drv.c
    ../../../modules/usb/: usb_task.c
    ../../../../common/lib_mcu/wdt/: wdt_drv.c
