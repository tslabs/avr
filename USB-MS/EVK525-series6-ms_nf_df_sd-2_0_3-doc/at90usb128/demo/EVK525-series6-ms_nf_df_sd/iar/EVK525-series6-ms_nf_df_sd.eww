<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EVK525-series6-ms_nf_df_sd.ewp</path>
  </project>
  <batchBuild/>
</workspace>


