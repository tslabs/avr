<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\STK525-series6-ms_df.ewp</path>
  </project>
  <batchBuild/>
</workspace>


